# IAR project bldc_foc.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32allasf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1101
  ICCAVR32.CCDiagSuppress: Pa082,Pe167,Pe193
  ICCAVR32.CCIncludePath2: ..\..\..\..\..\..\DRIVERS\; ..\..\..\..\..\..\DRIVERS\USBB\; ..\..\..\..\..\..\DRIVERS\USBB\ENUM\; ..\..\..\..\..\..\DRIVERS\USBB\ENUM\DEVICE\; ..\..\..\..\..\..\UTILS\; ..\..\..\..\..\..\UTILS\DEBUG\; ..\..\..\..\..\..\UTILS\PREPROCESSOR\; ..\..\..\..\..\..\BOARDS\; ..\..\..\..\..\..\SERVICES\UTILS\PREPROCESSOR\; ..\..\..\..\..\..\SERVICES\MOTOR_CONTROL\HALL_ESTIMATOR\; ..\..\..\..\..\..\SERVICES\MOTOR_CONTROL\MOTOR_DRIVER\BLDC_MOTOR\; ..\..\..\..\..\..\SERVICES\MOTOR_CONTROL\SVPWM\; ..\..\..\..\..\..\SERVICES\MOTOR_CONTROL\CONCORDIA\; ..\..\..\..\..\..\SERVICES\MOTOR_CONTROL\PARK\; ..\..\..\..\..\..\SERVICES\MOTOR_CONTROL\REGULATOR\; ..\..\..\..\..\..\SERVICES\FREERTOS\Source\portable\IAR\AVR32_UC3\; ..\..\..\..\..\..\SERVICES\USB\; ..\..\..\..\..\..\SERVICES\USB\CLASS\CDC\; ..\..\..\..\..\..\SERVICES\DELAY\; ..\..\..\..\..\..\UTILS\LIBS\DSPLIB\INCLUDE\; ..\..\..\..\..\..\UTILS\LIBS\DRIVERS\AT32UC3B\INCLUDE\; ..\..\; ..\..\CONF\; ..\..\ENUM\
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 2
  AAVR32.AIncludePaths: ..\..\..\..\..\..\UTILS\; ..\..\..\..\..\..\UTILS\PREPROCESSOR\; ..\..\..\..\..\..\UTILS\LIBS\DRIVERS\AT32UC3B\INCLUDE\; ..\..\ENUM\
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\..\..\..\..\..\UTILS\LINKER_SCRIPTS\AT32UC3B\0256\IAR\lnkuc3b0256.xcl
  group (top)
    ../../: main.c
  group libraries
    ../../../../../../UTILS/LIBS/DRIVERS/AT32UC3B/IAR/: libdrivers-at32uc3b-speed_opt.r82
    ../../../../../../UTILS/LIBS/DSPLIB/AT32UCR1/IAR/: libdsp-at32ucr1-dspspeed_opt.r82
  group services
    ../../../../../../SERVICES/MOTOR_CONTROL/CONCORDIA/: concordia.c
    ../../: delay.c foc.c mc_control.c mc_driver.c util.c
    ../../../../../../SERVICES/MOTOR_CONTROL/HALL_ESTIMATOR/: hall_estimator.c
    ../../../../../../SERVICES/MOTOR_CONTROL/REGULATOR/: ip_reg.c
    ../../../../../../SERVICES/MOTOR_CONTROL/PARK/: park.c
    ../../../../../../SERVICES/MOTOR_CONTROL/MOTOR_DRIVER/BLDC_MOTOR/: pwm_drv.c
    ../../../../../../SERVICES/MOTOR_CONTROL/SVPWM/: svpwm.c
  group support
    ../../../../../../DRIVERS/INTC/: exception.s82
    ../../../../../../SERVICES/FREERTOS/Source/portable/IAR/AVR32_UC3/: read.c write.c
    ../../../../../../SERVICES/USB/CLASS/DFU/EXAMPLES/ISP/BOOT/: trampoline.s82
  group usb
    ../../: device_cdc_task.c uart_usb_lib.c
    ../../../../../../UTILS/DEBUG/: print_funcs.c
    ../../ENUM/: usb_descriptors.c usb_specific_request.c
    ../../../../../../DRIVERS/USBB/ENUM/DEVICE/: usb_device_task.c usb_standard_request.c
    ../../../../../../DRIVERS/USBB/: usb_drv.c
    ../../../../../../DRIVERS/USBB/ENUM/: usb_task.c
